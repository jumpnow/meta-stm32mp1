PACKAGECONFIG:append = "arm-neon gles2"

EXTRA_OECMAKE += "-DSDL_OPENGL=OFF -DSDL_VULKAN=OFF -DSDL_WAYLAND=OFF -DSDL_X11=OFF"
