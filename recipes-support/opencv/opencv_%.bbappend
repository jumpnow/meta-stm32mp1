PACKAGECONFIG:remove = "eigen gapi gphoto2 gstreamer gtk libv4l python3 samples tbb tiff v4l"
